# Keil uVision project EV7736.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89C669 Philips
  cpu: IRAM(0-0x4FF) IROM(0-0x17FFF) XRAM (0-0x2FF) CLOCK(24000000) MX
  output: EV7736_UB_VX_X +hex
  c flags: Optimize=8
  link misc: REMOVEUNUSED
  group Startup
    ./: mainflow.c START_MX.A51
  group Application
    ./: maintmenu.c devicecheck.c CommonFunction.c GoodsWaySet.c SysParamSet.c countermaint.c RackSet.c
  group Core
    ./: common.c DataExchange.c SstFlash.c timer.c clock.c scheduler.c IOInput.c key.c casher.c Ds12887.c device.c Serial1.C serial.c initialization.c debug.c procotol.c CommModule.c communication.c mobile.c ShortMsg.c VMC_PC.c ITL.c BusCard.c lifterApi.c
  group heard
    ./: ITL.h maintmenu.h board.h global.h language.h mainflow.h devicecheck.h CommonFunction.h GoodsWaySet.h SysParamSet.h procotol.h countermaint.h RackSet.h IOInput.h mobile.h CommModule.h communication.h ShortMsg.h gprs.h key.h scheduler.h device.h VMC_PC.h Serial.h Serial1.h timer.h casher.h BusCard.h lifterApi.h
